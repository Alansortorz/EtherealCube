# Keil uVision project Dance.uvprojx, settings and files
target OLED_Test (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: OLED_Test
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,
  c include: ..\Libraries\FWlib\inc;..\Libraries\CMSIS;..\Users;..\Users\oled;..\Users\systick;..\Users\i2c;..\Users\mpu6050;..\Users\usart;..\Users\led;..\Users\key;..\Users\nrf;..\Users\beep;..\Users\time;..\Users\spi_flash;..\Users\hc05;..\Users\filter;..\Users\mpu6050\eMPL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
    ../Users/: main.c stm32f10x_it.c
    ../Users/systick/: bsp_systick.c
    ../Users/oled/: oled.c
    ../Users/led/: bsp_led.c
    ../Users/key/: bsp_key.c
    ../Users/time/: time.c
    ../Users/mpu6050/: mpu6050.c
    ../Users/i2c/: bsp_i2c.c
    ../Users/hc05/: hc05.c usart_blt.c
    ../Users/filter/: filter.c
    ../Users/mpu6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group DOC
    ../DOC/: Readme.txt
