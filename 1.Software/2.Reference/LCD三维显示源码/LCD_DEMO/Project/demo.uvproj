# Keil uVision project demo.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: demo +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\User
  group Source Group 1
    ../User/: main.c rtc.c
  group lcd
    ../User/: delay.c lcd_drive.c
  group dis
    ../User/: dis_general.c dis_graphics.c
  group draw
    ../User/: draw_line.c
  group matrix
    ../User/: transform_3D.c
  group project
    ../User/: projection.c
  group animat
    ../User/: font.c rotation_font3D.c rotation_cube.c
